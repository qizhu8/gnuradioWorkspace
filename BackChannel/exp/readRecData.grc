<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BandWidth</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_signal_dat</value></param>
<param><key>value</key><value>"/home/uone/gnuradio/gnuradioworkspace/BackChannel/dataSet/waveform_rec.dat"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_signal_dat_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"/home/uone/gnuradio/gnuradioworkspace/BackChannel/dataSet/waveform_rec_all_ones.dat"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_signal_dat_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>"/home/uone/gnuradio/gnuradioworkspace/BackChannel/dataSet/waveform_rec_all_zeros.dat"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/uone/rx_signal_dat+"_"+str(payloadSize)+".dat"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>64*8</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
