<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Filename</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/Users/yuwang/gnuradio/Workspace/MyGraph/LPF/raw_wav.wav</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>32000</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>file</key><value>Filename</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>4000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>In this program, I build a very simple recorder.
There are several key points you should remember:

1. Make sure the output and input of the connection
 are of the same size.
When you connect the "Audio Source" with "Low Pass 
Filter", you may find the connection arror is red, which
means there is an error. The reason is that the defaut 
output for Audio Source is float(4bit). While the default
input for LPF is complex(8bit). So, you should change the
LPF's input size to "float"

Also, the error will disappear when connected to the wav
sink;

2. Usage of Parameter and Variable
There is a block called Variable, and the default project 
has one Variable block called "samp_rate"
Variable is only used to store value.

In this project, we set the filename of the output file to be
a 'Variable'. We need to use 'Parameter' block.
Pay attention, you should use absolute path, and you 
should not use '~' to indicate the userpath. No need to 
cover the path with quotation mark "".

by Yu Wang, Nov 10</value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
